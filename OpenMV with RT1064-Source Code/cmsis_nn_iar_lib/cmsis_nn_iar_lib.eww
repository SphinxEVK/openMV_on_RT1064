<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cmsis_nn_iar_lib.ewp</path>
    </project>
    <batchBuild />
</workspace>
